# Keil uVision project STM32F4_ADK.uvproj, settings and files
target STM32F4-ADK (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4_ADK
  c flags: Optim=2 OneElfS=1
  c define: STM32F4XX USE_STDPERIPH_DRIVER USB_OTG_HS_CORE USE_USB_OTG_FS DEBUG
  c include: ..\inc;..\src;..\Utilities\STM32_EVAL;..\Libraries\CMSIS\Include;..\Libraries\Device\STM32F4xx\Include;..\Libraries\Device\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: startup_stm32f4xx.mdk.s
    ../src/: system_stm32f4xx.c main.c stm32f4xx_it.c uart_debug.c usb_bsp.c usbh_adk_core.c usbh_usr.c xprintf.c
    ../Utilities/STM32_EVAL/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group STM32_USB_HOST_Library
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group STM32_USB_OTG_Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
